Commit message: Bug fix

File: urdf/thorvald_arm.urdf (robot description, URDF)
Before this commit: robot thorvald_arm, 1 links, 5 joints
Joints:
- joint joint_5: axis 0 0 1 -> 0 1 0

Commit message: Thorvald arc with arms

File: urdf/thorvald_arc.urdf (robot description, URDF)
Before this commit: robot thorvald_arm, 1 links, 0 joints
Links:
- link base_link: geometry 
Joints:
- added joint arc_joint: type fixed, parent base_link, child arc_link, origin xyz=0 0 0 rpy=0 0 0
